# Keil uVision project mcp_integration.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.3.2.1
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(26000000) ELITTLE
  output: mcp_integration +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CHIPSEL_594X
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group Application
    ./src/: main.c retarget.c
  group Drivers
    ./src/: uart_hal.c spi_hal.c mcp2515.c
  group AD5940
    ./src/: ad5940.c ADICUP3029Port.c BATImpedance.c
software components: CMSIS:CORE 5.5.0, Device:Global Configuration 3.2.0, Device:Startup 3.2.0
